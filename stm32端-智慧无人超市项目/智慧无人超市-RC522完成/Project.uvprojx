# Keil uVision project Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\FreeRTOS\include;.\FreeRTOS\portable\MemMang;.\FreeRTOS\portable\RVDS\ARM_CM3;.\FreeRTOS\CMSIS_RTOS_V2;.\FreeRTOS;.\Hardware\LED;.\Hardware\OLED;.\Hardware\Serial;.\Hardware\BEEP;.\Hardware\Servo;.\Hardware\ESP8266;.\Delay;.\Hardware\RC522
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group Delay
    ./Delay/: Delay.c
  group Hardware
    ./Hardware/LED/: LED.c
    ./Hardware/OLED/: OLED.c
    ./Hardware/Serial/: Serial.c
    ./Hardware/BEEP/: BEEP.c
    ./Hardware/Servo/: Servo.c
    ./Hardware/ESP8266/: ESP8266.c
    ./Hardware/RC522/: rc522.c
  group FreeRTOS
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/CMSIS_RTOS_V2/: cmsis_os2.c
    ./FreeRTOS/include/: FreeRTOSConfig.h
  group User
    ./FreeRTOS/: freertos.c
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
